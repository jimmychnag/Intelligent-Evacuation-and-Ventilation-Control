# Keil uVision project AutoDoor.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: AutoDoor +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware;.\Library;.\System;.\User
  group System
    ./: STARTUP.A51
    ./System/: Delay.c Delay.h
  group Hardware
    ./Hardware/: DS18B20.c DS18B20.h OneWire.c OneWire.h I2C_8051.c I2C_8051.h LCD1602.c LCD1602.h Timer0_Servo.c Timer0_Servo.h INT.c INT.h Uart.c Uart.h
  group User
    ./User/: AutoDoor.c
